# Keil uVision project demcu.uvproj, settings and files
target demcu (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: demcu +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src\header
  group src.startup
    ./src/startup/: STARTUP.A51
  group src.app
    ./src/app/: main.c
  group src.widget
    ./src/widget/: uart_print.c
  group src.hal
    ./src/hal/: nrf24l01.c
  group src.hw
    ./src/hw/: nrf24l01_hw.c soft_spi.c
  group src.mcu
    ./src/mcu/: mcu.c
